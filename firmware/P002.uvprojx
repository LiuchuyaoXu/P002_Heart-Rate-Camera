# Keil uVision project P002.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL03Z32VFK4 NXP
  pack: NXP.MKL03Z4_DFP.10.0.1
  cpu: IRAM(0x1ffffe00,0x0800) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: P002
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffe00 size 0x800
